Commit message: Implement force control

File: ur_pykdl/urdf/b_bot.urdf (robot description, URDF)
Before this commit: robot o2ac_base_scene, 53 links, 52 joints
Joints:
- joint b_bot_robotiq_140_base_joint: parent a_bot_tool0 -> b_bot_tool0
