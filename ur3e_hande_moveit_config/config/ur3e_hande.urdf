Commit message: update moveit config

File: ur3e_hande_moveit_config/config/ur3e_hande.urdf (robot description, URDF)
Before this commit: robot ur3, 17 links, 16 joints
Links:
- removed link aruco_marker
Joints:
- removed joint aruco_dummy_joint
